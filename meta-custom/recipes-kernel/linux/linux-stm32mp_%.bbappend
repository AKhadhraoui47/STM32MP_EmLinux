FILESEXTRAPATHS:prepend := "${THISDIR}/stm32mp1:"
SRC_URI += "file://0001-enable-uart8.patch file://0002-grovewifiv2-dts.patch"

